<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fm_radio</value></param>
<param><key>author</key><value>Brian McLaughlin (bjmclaughlin@gmail.com)</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>FM Radio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baseband_decimation</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baseband_rate</value></param>
<param><key>value</key><value>samp_rate // baseband_decimation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_broadcast_high</value></param>
<param><key>value</key><value>107.9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_broadcast_low</value></param>
<param><key>value</key><value>87.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_broadcast_seperation</value></param>
<param><key>value</key><value>0.2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fm_station</value></param>
<param><key>value</key><value>102.7</value></param>
<param><key>gui_hint</key><value>0, 0, 1, 1</value></param>
<param><key>label</key><value>FM Station</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>fm_broadcast_low</value></param>
<param><key>step</key><value>fm_broadcast_seperation</value></param>
<param><key>stop</key><value>fm_broadcast_high</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rds_bitrate</value></param>
<param><key>value</key><value>1.1875e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rds_dec</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rds_samp_rate</value></param>
<param><key>value</key><value>baseband_rate / rds_dec</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rds_subcarrier</value></param>
<param><key>value</key><value>57e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.048e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>slider_volume</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>notebook_top@2:0, 0, 1, 1</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>5</value></param>
<param><key>widget</key><value>dial</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0_0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>1</value></param>
<param><key>quad_rate</key><value>baseband_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>19.5e3</value></param>
<param><key>low_cutoff_freq</key><value>18.5e3</value></param>
<param><key>samp_rate</key><value>baseband_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>53e3</value></param>
<param><key>low_cutoff_freq</key><value>23e3</value></param>
<param><key>samp_rate</key><value>baseband_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_1</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>38.5e3</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>37.5e3</value></param>
<param><key>samp_rate</key><value>baseband_rate</value></param>
<param><key>width</key><value>0.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_1_0</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>(19e3 * 3) + 0.5e3</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>(19e3 * 3) - 0.5e3</value></param>
<param><key>samp_rate</key><value>baseband_rate</value></param>
<param><key>width</key><value>0.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/brian/fm_radio/rds_data.bin</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>2</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>1000000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>slider_volume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>100000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_mpsk_receiver_cc</key>
<param><key>id</key><value>digital_mpsk_receiver_cc_0</value></param>
<param><key>gain_mu</key><value>0.05</value></param>
<param><key>gain_omega</key><value>0.001</value></param>
<param><key>w</key><value>1*cmath.pi/100.0</value></param>
<param><key>M</key><value>2</value></param>
<param><key>fmax</key><value>0.06</value></param>
<param><key>fmin</key><value>-0.06</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>rds_samp_rate / (rds_bitrate * 2)</value></param>
<param><key>theta</key><value>0</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_1_0</value></param>
<param><key>center_freq</key><value>rds_subcarrier</value></param>
<param><key>decim</key><value>rds_dec</value></param>
<param><key>samp_rate</key><value>baseband_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(2500.0,baseband_rate, 2.4e3, 2e3, firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>fcc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>60e3</value></param>
<param><key>decim</key><value>baseband_decimation</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>cutoff_freq</key><value>15e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>10</value></param>
<param><key>samp_rate</key><value>baseband_rate</value></param>
<param><key>width</key><value>3e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2</value></param>
<param><key>cutoff_freq</key><value>16e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>baseband_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>notebook_rds</value></param>
<param><key>gui_hint</key><value>notebook_top@5:0, 0, 1, 1</value></param>
<param><key>label0</key><value>RDS Spectrum</value></param>
<param><key>label1</key><value>RDS Signal</value></param>
<param><key>label2</key><value>Constellation</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>notebook_subcarriers</value></param>
<param><key>gui_hint</key><value>notebook_top@3:0, 0, 1, 1</value></param>
<param><key>label0</key><value>Pilot Signal</value></param>
<param><key>label1</key><value>Spectrum</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>notebook_top</value></param>
<param><key>gui_hint</key><value>1, 0, 1, 1</value></param>
<param><key>label0</key><value>RF Receive</value></param>
<param><key>label1</key><value>Baseband</value></param>
<param><key>label2</key><value>Mono Audio</value></param>
<param><key>label3</key><value>Sub-Carrier Generation</value></param>
<param><key>label4</key><value>Stereo</value></param>
<param><key>label5</key><value>RDS</value></param>
<param><key>num_tabs</key><value>6</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>notebook_rds@2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>fm_station * 1e6</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>notebook_top@0:0, 1, 1, 1</value></param>
<param><key>name</key><value>RF Frequency</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-40</value></param>
<param><key>ymin</key><value>-80</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.1</value></param>
<param><key>bw</key><value>baseband_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>notebook_top@1:0, 1, 1, 1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>FM Baseband</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-30</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>audio_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>notebook_top@2:1, 0, 1, 5</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>Mono Audio (L+R)</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-30</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_1_0</value></param>
<param><key>average</key><value>0.1</value></param>
<param><key>bw</key><value>audio_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>notebook_top@4:0, 1, 1, 1</value></param>
<param><key>name</key><value>Stereo Signal (L-R)</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-30</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_1_0_0</value></param>
<param><key>average</key><value>0.1</value></param>
<param><key>bw</key><value>baseband_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>notebook_subcarriers@1:0, 0, 1, 1</value></param>
<param><key>label1</key><value>Pilot Tone</value></param>
<param><key>label2</key><value>Stereo Carrier</value></param>
<param><key>label3</key><value>RDS Carrier</value></param>
<param><key>name</key><value>RF Frequency</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-50</value></param>
<param><key>ymin</key><value>-80</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>rds_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>notebook_rds@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>notebook_subcarriers@0:0, 1, 1, 1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>19 KHz Pilot Signal</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>baseband_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>yunit</key><value>counts</value></param>
<param><key>ymax</key><value>0.004</value></param>
<param><key>ymin</key><value>-0.004</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>gui_hint</key><value>notebook_rds@1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>rds_bitrate * 2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(baseband_rate)</value></param>
<param><key>interp</key><value>int(audio_rate)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>int(baseband_rate)</value></param>
<param><key>interp</key><value>int(audio_rate)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>100</value></param>
<param><key>samp_rate</key><value>rds_samp_rate</value></param>
<param><key>sym_rate</key><value>2375</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>1</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>corr0</key><value>9</value></param>
<param><key>freq0</key><value>fm_station * 1e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>1</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>49.6</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_baseband</value></param>
<param><key>stream_id</key><value>baseband</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_baseband_source</value></param>
<param><key>stream_id</key><value>baseband</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_baseband_source_0</value></param>
<param><key>stream_id</key><value>baseband</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_baseband_source_0_0</value></param>
<param><key>stream_id</key><value>baseband</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_baseband_source_0_0_0</value></param>
<param><key>stream_id</key><value>baseband</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>pilot_tone</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>stereo_subcarrier</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_0</value></param>
<param><key>stream_id</key><value>rds_subcarrier</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>pilot_tone</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>pilot_tone</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>pilot_tone</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>stereo_subcarrier</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0</value></param>
<param><key>stream_id</key><value>rds_subcarrier</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>stereo_subcarrier</value></param>
</block>
<connection><source_block_id>analog_fm_deemph_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_deemph_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_deemph_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>virtual_baseband</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_1</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_1_0</source_block_id><sink_block_id>virtual_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>band_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>band_pass_filter_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>low_pass_filter_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_mpsk_receiver_cc_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_mpsk_receiver_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_mpsk_receiver_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_1_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_1_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_fm_deemph_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>analog_fm_deemph_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>digital_mpsk_receiver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_baseband_source</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_baseband_source_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_baseband_source_0_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_baseband_source_0_0_0</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
